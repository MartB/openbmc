KBRANCH ?= "dev-6.6"
LINUX_VERSION ?= "6.6.98"

SRCREV = "6004f0a07117a9c7cec5b59a897930182a316a69"

require linux-aspeed.inc
